# Keil uVision project cosinusoneupdate.uvprojx, settings and files
target cosinus1update (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52_mpw3 +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF52 DEBUG_NRF BOARD_PCA10036 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0 DEBUG BSP_DEFINES_ONLY
  c misc: --c99
  c include: .\components\drivers_nrf\gpiote;.\components\drivers_nrf\common;.\components\drivers_nrf\delay;.\components\drivers_nrf\uart;.\components\drivers_nrf\twi_master;.\components\drivers_nrf\common;.\components\drivers_nrf\config;.\components\device;.\components\toolchain;.\components\libraries\button;.\components\libraries\fifo;.\components\libraries\uart;.\components\libraries\util;.\components\libraries\timer;.\components;.\components\drivers_nrf\nrf_soc_nosd;.\components\drivers_nrf\hal;.\components\drivers_nrf\twis_slave;..\arm5_no_packs;.\components\libraries\twi;..\components\drivers_nrf\i2s;C:\Keil_v5\ARM\ARMCC\include\rw;C:\Keil_v5\ARM\ARMCC\include;..\i2s;.\components\drivers_nrf\rtc;.\components\drivers_nrf\clock
  asm define: NRF52 DEBUG_NRF BOARD_PCA10036 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c general_defination.h i2c1_master.c i2c1_master_public.h audiocodec.c audiocodec_config.h audiocodec_public.h i2s_master.c i2s_master_public.h real_time_clock.c real_time_clock.h switch.c switch.h
  group Documentation
    ./: notes.txt scrap.txt testdata_i2s.txt
  group nRF_Drivers
    ./components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ./components/drivers_nrf/delay/: nrf_delay.c
    ./components/drivers_nrf/common/: nrf_drv_common.c
    ./components/drivers_nrf/i2s/: nrf_drv_i2s.c
    ./components/drivers_nrf/clock/: nrf_drv_clock.c
    ./components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ./components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ./components/drivers_nrf/ppi/: nrf_drv_ppi.c
  group nRF_Libraries
    ./components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c app_error_weak.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
